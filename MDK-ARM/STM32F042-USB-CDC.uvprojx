# Keil uVision project STM32F042-USB-CDC.uvprojx, settings and files
target STM32F042-USB-CDC (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F042K6 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x200017FF) IROM(0x8000000-0x8007FFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: STM32F042-USB-CDC +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F042x6
  c include: ../Inc;../Drivers/STM32F0xx_HAL_Driver/Inc;../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32F0xx/Include;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1800
  group Application/MDK-ARM
    ./: startup_stm32f042x6.s
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_iwdg.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_cortex.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_i2c.c stm32f0xx_hal_rcc.c stm32f0xx_hal_gpio.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_dma.c stm32f0xx_hal_pwr.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_pcd.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_pcd_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_adc.c stm32f0xx_hal_uart.c stm32f0xx_hal.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_flash.c stm32f0xx_hal_rcc_ex.c
  group Drivers/CMSIS
    ..//Src/: system_stm32f0xx.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Application/User
    ../Src/: usb_device.c stm32f0xx_it.c usbd_cdc_if.c usbd_conf.c main.c stm32f0xx_hal_msp.c usbd_desc.c
software components: CMSIS:CORE 4.3.0
